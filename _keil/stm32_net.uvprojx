# Keil uVision project stm32_net.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_net
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\inc;..\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\enc28j60\inc;C:\Keil_v5;..\uIP;..\uIP\lib;..\app;..\fs\inc;..\sd_mmc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\stm32_net.sct
  group src
    ../src/: stm32net.c clock-arch.c
  group STD_lib
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c misc.c
  group enc28j60_driver
    ../enc28j60/src/: enc28j60.c
  group uip
    ../uIP/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group httpd
    ../app/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
  group fs
    ../fs/: diskio.c ff.c
  group sd_mmc
    ../sd_mmc/: mmc.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 1.0.0
